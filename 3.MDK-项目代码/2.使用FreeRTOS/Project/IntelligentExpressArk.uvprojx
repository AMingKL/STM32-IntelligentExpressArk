# Keil uVision project IntelligentExpressArk.uvprojx, settings and files
target IntelligentExpressArk (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: IntelligentExpressArk +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Users;..\Hardware\sys;..\Hardware\delay;..\Hardware\GPIO;..\Hardware\USART3;..\Hardware\AS608;..\Hardware\Tim3;..\Hardware\USART1;..\Hardware\USART2;..\Hardware\gsm;..\Hardware\nvic;..\RTOS\port\RVDS\ARM_CM3;..\RTOS\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/STARTUP/: startup_stm32f10x_md.s
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group USER
    ../Users/: main.c stm32f10x_it.c stm32f10x_conf.h myconfig.h FreeRTOSConfig.h
  group HARDWARE
    ../Hardware/sys/: sys.c
    ../Hardware/delay/: delay.c
    ../Hardware/GPIO/: gpio.c
    ../Hardware/USART3/: usart3.c
    ../Hardware/Tim3/: tim3.c
    ../Hardware/AS608/: as608.c
    ../Hardware/USART1/: usart1.c
    ../Hardware/USART2/: usart2.c
    ../Hardware/gsm/: sim800c.c
    ../Hardware/nvic/: nvic.c
  group FreeRTOS/srs
    ../RTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../RTOS/port/MemMang/: heap_4.c
    ../RTOS/port/RVDS/ARM_CM3/: port.c
  group DOC
    ../DOC/: bsp_xx.c bsp_xx.h Read me.txt
