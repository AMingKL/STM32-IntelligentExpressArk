# Keil uVision project IntelligentExpressArk.uvprojx, settings and files
target IntelligentExpressArk (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: IntelligentExpressArk +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Hardware\sys;..\Hardware\delay;..\Hardware\GPIO;..\Hardware\USART3;..\Hardware\AS608;..\Hardware\Tim3;..\Hardware\TIM4;..\Hardware\USART1;..\Hardware\USART2;..\Hardware\Flash;..\Hardware\gsm;..\Hardware\nvic;..\..\2.使用FreeRTOS\RTOS\include;..\..\2.使用FreeRTOS\RTOS\port\RVDS\ARM_CM3;..\..\2.使用FreeRTOS\Users
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/STARTUP/: startup_stm32f10x_md.s
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group USER
    ../Users/: main.c stm32f10x_it.c stm32f10x_conf.h myconfig.c myconfig.h
    ../../2.使用FreeRTOS/Users/: FreeRTOSConfig.h
    ../../2.使用FreeRTOS/RTOS/include/: FreeRTOS.h
  group HARDWARE
    ../Hardware/sys/: sys.c
    ../Hardware/delay/: delay.c
    ../Hardware/GPIO/: gpio.c
    ../Hardware/USART3/: usart3.c
    ../Hardware/Tim3/: tim3.c
    ../Hardware/AS608/: as608.c
    ../Hardware/TIM4/: tim4.c
    ../Hardware/USART1/: usart1.c
    ../Hardware/USART2/: usart2.c
    ../Hardware/Flash/: stmflash.c
    ../Hardware/gsm/: sim800c.c
    ../Hardware/nvic/: nvic.c
  group FreeRTOS/src
    ../../2.使用FreeRTOS/RTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../../2.使用FreeRTOS/RTOS/port/RVDS/ARM_CM3/: port.c
    ../../2.使用FreeRTOS/RTOS/port/MemMang/: heap_4.c
  group DOC
    ../../2.使用FreeRTOS/DOC/: bsp_xx.c Read me.txt bsp_xx.h
